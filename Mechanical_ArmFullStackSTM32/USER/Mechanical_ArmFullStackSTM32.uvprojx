# Keil uVision project Mechanical_ArmFullStackSTM32.uvprojx, settings and files
target Mechanical_ArmFullStackSTM32 (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SFHW\LED;..\SFILB\delay;..\SFILB\sys;..\SFILB\COMMON_USART;..\SFILB\PWM;..\SFILB\TIMER;..\SFHW\KEY;..\SFHW\OLED;..\SFHW\USART;..\SFILB\ARM;..\SFILB\Data;..\SFHW\WIFI;..\SFHW\LCD;..\SFHW\SHT11
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c
  group SFHW
    ../SFHW/LED/: led.c
    ../SFHW/KEY/: key.c
    ../SFHW/OLED/: oled.c
    ../SFHW/USART/: USB_To_Usart.c
    ../SFHW/WIFI/: WIFI_E103_W02.c
    ../SFHW/LCD/: lcd.c
    ../SFHW/SHT11/: sht11.c
  group SFLIB
    ../SFILB/COMMON_USART/: CommonUsart.c
    ../SFILB/delay/: delay.c
    ../SFILB/PWM/: PWM_PB67.c
    ../SFILB/sys/: sys.c
    ../SFILB/TIMER/: timer.c
    ../SFILB/ARM/: arm.c
    ../SFILB/Data/: Data_.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_usart.c misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_cryp.c stm32f4xx_tim.c stm32f4xx_fsmc.c
